# file: Keypad_LCD.ioc
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Mcu.Family=STM32F4
Mcu.Name=STM32F439Z(G-I)Tx
Mcu.Package=LQFP144
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
RCC.AHBFreq_Value=16000000
RCC.APB1Freq_Value=16000000
RCC.APB2Freq_Value=16000000
RCC.CortexFreq_Value=16000000
RCC.HSE_VALUE=25000000
RCC.HSI_VALUE=16000000
RCC.LSE_VALUE=32768
RCC.SYSCLKFreq_VALUE=16000000
RCC.VCOOutputFreq_Value=192000000
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2023 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"
#include "../ECUAL/KEYPAD/KEYPAD.h"
#include "../ECUAL/LCD16x2/LCD16x2.h"

#define KEY_1       1
#define KEY_2       2
#define KEY_3       3
#define KEY_4       4
#define KEY_5       5
#define KEY_6       6
#define KEY_7       7
#define KEY_8       8
#define KEY_9       9
#define KEY_A       A
#define KEY_B       B
#define KEY_C       C
#define KEY_D       D
#define KEY_0       0
#define KEY_star    s
#define KEY_E       E

uint8_t gu8_KeyStatesArr[KEYS] = {0};
uint8_t SysTicks = 0;

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
void SysTick_CallBack(void);
void Display_Handler(void);

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */
  MX_GPIO_Init();
  /* USER CODE BEGIN 2 */
  KEYPAD_Init(0, gu8_KeyStatesArr);
  LCD_Init();
  LCD_Clear();
  LCD_Set_Cursor(1, 1);
  /* USER CODE END 2 */

  /* Infinite loop */
  while (1)
  {
	  Display_Handler();
	  HAL_Delay(10);
  }
}
void SysTick_CallBack(void)
{
    SysTicks++;
    if(SysTicks == 5) // Each 5msec
    {
    KEYPAD_Scan(0);
    SysTicks = 0;
    }
}

void Display_Handler(void)
{
    if(gu8_KeyStatesArr[KEY_1] == KEY_PRESSED)
    {
    LCD_Write_Char('1');
    while(gu8_KeyStatesArr[KEY_1] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_2] == KEY_PRESSED)
    {
    LCD_Write_Char('2');
    while(gu8_KeyStatesArr[KEY_2] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_3] == KEY_PRESSED)
    {
    LCD_Write_Char('3');
    while(gu8_KeyStatesArr[KEY_3] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_4] == KEY_PRESSED)
    {
    LCD_Write_Char('4');
    while(gu8_KeyStatesArr[KEY_4] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_5] == KEY_PRESSED)
    {
    LCD_Write_Char('5');
    while(gu8_KeyStatesArr[KEY_5] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_6] == KEY_PRESSED)
    {
    LCD_Write_Char('6');
    while(gu8_KeyStatesArr[KEY_6] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_7] == KEY_PRESSED)
    {
    LCD_Write_Char('7');
    while(gu8_KeyStatesArr[KEY_7] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_8] == KEY_PRESSED)
    {
    LCD_Write_Char('8');
    while(gu8_KeyStatesArr[KEY_8] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_9] == KEY_PRESSED)
    {
    LCD_Write_Char('9');
    while(gu8_KeyStatesArr[KEY_9] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_0] == KEY_PRESSED)
    {
    LCD_Write_Char('0');
    while(gu8_KeyStatesArr[KEY_0] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_A] == KEY_PRESSED)
    {
    LCD_Write_Char('A');
    while(gu8_KeyStatesArr[KEY_A] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_B] == KEY_PRESSED)
    {
    LCD_Write_Char('B');
    while(gu8_KeyStatesArr[KEY_B] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_C] == KEY_PRESSED)
    {
    LCD_Write_Char('C');
    while(gu8_KeyStatesArr[KEY_C] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_D] == KEY_PRESSED)
    {
    LCD_Write_Char('D');
    while(gu8_KeyStatesArr[KEY_D] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_star] == KEY_PRESSED)
    {
    LCD_Write_Char('*');
    while(gu8_KeyStatesArr[KEY_star] == KEY_PRESSED);
    }
    if(gu8_KeyStatesArr[KEY_E] == KEY_PRESSED)
    {
    LCD_Write_Char('#');
    while(gu8_KeyStatesArr[KEY_E] == KEY_PRESSED);
    }
}

void SystemClock_Config(void)
{
	  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
	  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

	  /** Initializes the CPU, AHB and APB busses clocks
	  */
	  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
	  RCC_OscInitStruct.HSEState = RCC_HSE_ON;
	  RCC_OscInitStruct.HSEPredivValue = RCC_HSE_PREDIV_DIV1;
	  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
	  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
	  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
	  RCC_OscInitStruct.PLL.PLLMUL = RCC_PLL_MUL9;
	  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
	  {
	    Error_Handler();
	  }
	  /** Initializes the CPU, AHB and APB busses clocks
	  */
	  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
	                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
	  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
	  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
	  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV2;
	  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

	  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_2) != HAL_OK)
	  {
	    Error_Handler();
	  }
}
static void MX_GPIO_Init(void)
{
	  /* GPIO Ports Clock Enable */
	  __HAL_RCC_GPIOD_CLK_ENABLE();

}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
